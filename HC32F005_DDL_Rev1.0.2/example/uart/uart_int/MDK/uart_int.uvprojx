# Keil uVision project uart_int.uvprojx, settings and files
target uart_int_Release (ARM-ADS)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cabinet_light +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../../mcu/common/: system_hc32f005.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32f005.c clk.c uart.c bt.c lpm.c gpio.c protocol.c system.c mcu_api.c pca.c adt.c flash.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
